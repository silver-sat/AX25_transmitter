options:
  parameters:
    generate_options: qt_gui
    id: AX25_Tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: data_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 145.835E6
  states: {}
- name: multiplier
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: data_rate*multiplier
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 3e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '5000'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: multiplier
    type: byte
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[0.06480373442173004,0.14118190109729767,0.24622690677642822,0.3437711000442505,0.38422060012817383,0.3437711000442505,0.24622690677642822,0.14118190109729767,0.06480373442173004,0.02381213940680027]'
    type: fff
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '10000'
    port: '1234'
    type: UDP_SERVER
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: localhost
    header: '0'
    payloadsize: '1472'
    port: '7355'
    send_eof: 'True'
    type: short
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    samp_per_symbol: multiplier
    size: '512'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_hdlc_framer_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '8'
    preamble_bytes: '48'
  states: {}
- name: satellites_kiss_to_pdu_0
  id: satellites_kiss_to_pdu
  parameters:
    control_byte: 'True'
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Video_Out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Video_Out
  states: {}

connections:
- [analog_nbfm_tx_0, '0', soapy_plutosdr_sink_0, '0']
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_short_0, '0', network_udp_sink_0, '0']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_1, '0', virtual_sink_0, '0']
- [digital_scrambler_bb_0, '0', blocks_repeat_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_1, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', satellites_kiss_to_pdu_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', satellites_nrzi_encode_0, '0']
- [satellites_hdlc_framer_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_kiss_to_pdu_0, out, satellites_hdlc_framer_0, in]
- [satellites_nrzi_encode_0, '0', digital_scrambler_bb_0, '0']
- [virtual_source_0, '0', analog_nbfm_tx_0, '0']
- [virtual_source_0, '0', blocks_float_to_short_0, '0']
- [virtual_source_0, '0', qtgui_eye_sink_x_0, '0']

metadata:
  file_format: 1
